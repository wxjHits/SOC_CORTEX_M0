# Keil uVision project cm0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: cm0
  AfterMake: fromelf -cvf .\cm0.axf --vhx --32x1 -o image.hex
  AfterMake: fromelf -cvf .\cm0.axf -o image.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Software
  asm include: ..\Software;..\Keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ../Software/: core_cmFunc.h core_cmInstr.h CortexM0.h CortexM0_driver.c CortexM0_driver.h handler.c main.c Retarget.c startup_CM0DS.s system.c core_cm0.h lcdfont.h camera.c camera_initial_reg_file.h
